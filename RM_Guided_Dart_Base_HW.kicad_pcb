# Repository Echo-RWN/RM_Guided_Dart

## KiCad design RM_Guided_Dart_Base_HW.kicad_pcb

Parts:
D1: G; LED_0402_1005Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1: CSI; FPC-SMD_22P-P1.00_AFC11-S22ICC-00
J2: DSI; Hirose_FH26-31S-0.3SHW_2Rows-31Pins-1MP_P0.60mm_Horizontal
J3: JTAG; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
J4, J9: PWM4; Connector_Servo_JR_3P_2.54mm_WirePad
J5: UART3; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
J6: PWM1; Connector_Servo_JR_3P_2.54mm_WirePad
J7: PWM2; Connector_Servo_JR_3P_2.54mm_WirePad
J8: PWM3; Connector_Servo_JR_3P_2.54mm_WirePad
R1, R2, R3, R5, R7: 33R; R_0402_1005Metric
R4: 1k; R_0402_1005Metric
R6: 33R; R_0603_1608Metric
SW1: SW_Push; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS
U1: LicheeRV_Nano; LicheeRV_Nano_THT
U2: XIAO-ESP32-C5-DIP; XIAO-ESP32-C5-SMD

Connections:
+1V8_SYS_1: J2.6
+1V8_SYS_2: J2.3
+3V3: R4.1; also elsewhere on the board
+3V3_ESP32-C5: U2.12 (3V3)
+3V3_SYS_1: U1.15 (3V3)
+3V3_SYS_2: J1.22
+3V3_SYS_3: J2.2
+3V3_SYS_4: J2.1
+5V: J3.1, J4.2, J5.1, U1.13 (VSYS), U1.14 (VBUS), U2.14 (VBUS); also elsewhere on the board
+7V2: J6.2, J7.2, J8.2, J9.2; also elsewhere on the board
/CAM_IO0: J1.17; also elsewhere on the board
/CAM_IO1: J1.18; also elsewhere on the board
/CAM_SCL: J1.20; also elsewhere on the board
/CAM_SDA: J1.21; also elsewhere on the board
/CS1_Accel: U1.11 (GPIOA_22/EMMC_CLK/SPI1_SCK); also elsewhere on the board
/CS2_Gyro: U1.8 (GPIOA_23/EMMC_CMD/SPI1_MISO); also elsewhere on the board
/IMU_SPI2-CS: U1.22 (SDIO1_D3/SPI2_CS/PWM_4/I2C1_SCL/UART3_C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)
/IMU_SPI2-MISO: U1.20 (SDIO1_D0/SPI2_MISO/PWM_7/I2C1_SDA/UART3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); also elsewhere on the board
/IMU_SPI2-MOSI: R6.2; also elsewhere on the board
/IMU_SPI2-SCK: R7.2; also elsewhere on the board
/INT1_Accel: U1.7 (GPIOA_24/EMMC_D1/SPI1_CS); also elsewhere on the board
/INT2_Accel: U1.10 (GPIOA_25/EMMC_D0/SPI1_MOSI); also elsewhere on the board
/INT3_Gyro: U1.12 (GPIOA_26/EMMC_D2); also elsewhere on the board
/JTAG_TCK: J3.3, U1.27 (PWM_6/JTAG_TCK/UART1_RTS/UART1_TX/GPIOA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)
/JTAG_TDI: J3.5, U1.23 (JTAG_TDI/UART1_TX/UART2_TX/GPIOA_28)
/JTAG_TDO: J3.4, U1.25 (JTAG_TDO/UART1_RX/UART2_RX/GPIOA_29)
/JTAG_TMS: J3.2, U1.28 (PWM_7/JTAG_TMS/UART1_CTS/UART1_RX/GPIOA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)
/LCD0_BL+: J2.29, J2.30, J2.31
/LCD0_BL-: J2.24, J2.25, J2.26, J2.27
/LCD0_RESET: J2.5
/MIPI_RX0_N: R3.2; also elsewhere on the board
/MIPI_RX0_P: J1.15
/MIPI_RX1_N: J1.11
/MIPI_RX1_P: J1.12
/MIPI_RX2_N: J1.8; also elsewhere on the board
/MIPI_RX2_P: J1.9; also elsewhere on the board
/MIPI_RX3_N: J1.5; also elsewhere on the board
/MIPI_RX3_P: J1.6; also elsewhere on the board
/MIPI_RX4_N: J1.2; also elsewhere on the board
/MIPI_RX4_P: J1.3; also elsewhere on the board
/PWM1: J6.1, U1.2 (GPIOA_16/UART0_TX/PWM_4)
/PWM2: J7.1, U1.1 (GPIOA_17/UART0_RX/PWM_5)
/PWM3: J2.11, J8.1
/PWM4: J2.12, J9.1
/SPI0_CS: J2.18, U2.1 (GPIO1_A0_D0)
/SPI0_HANDSHAKE: U1.9 (GPIOA_27/EMMC_D3), U2.3 (GPIO25_D2)
/SPI0_SCK: R2.1, U2.9 (GPIO8_D8_SCK)
/SPI0_SDI: J2.15, R5.2
/SPI0_SDO: R1.1, U2.11 (GPIO18_D10_MOSI)
/UART: J4.3
/UART3_RX: J5.3, U1.17 (SDIO1_D1/PWM_6/UART3_RX/GPIOP_20)
/UART3_TX: J5.2, U1.21 (SDIO1_D2/PWM_5/UART3_TX/GPIOP_19)
GND: H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), J1.1, J1.4, J1.7, J1.10, J1.13, J1.16, J1.19, J1.MP (MountPin), J2.4, J2.7, J2.10, J2.13, J2.19, J2.22, J2.23, J2.MP (MountPin), J3.6, J3.MP (MountPin), J4.1, J5.4, J5.MP (MountPin), J6.3, J7.3, J8.3, J9.3, SW1.1, U1.3 (GND), U1.26 (GND), U2.13 (GND); also elsewhere on the board
unnamed: D1.2 (A), R4.2
unnamed: D1.1 (K), U1.4 (GPIOA_15)
unnamed: J1.14, R3.1
unnamed: J2.14, R1.2
unnamed: J2.17, R2.2
unnamed: SW1.2, U1.16 (GPIOA_14)
unnamed: R7.1, U1.18 (SDIO1_CLK/SPI2_SCK/PWM_9/I2C3_SDA/GPIOP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)
unnamed: R6.1, U1.19 (SDIO1_CMD/SPI2_MOSI/PWM_8/I2C3_SCL/GPIO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)
unnamed: R5.1, U2.10 (GPIO9_D9_MISO)
V_IN: U1.24 (ADC/GPIOB_3); also elsewhere on the board

Notes on the sheet:
已解决
PWM[15]
未使用
双通道开关瞬间会有大电流，直接上电反而不会， 同时TP5100会瞬间烧穿，目前未排查出原因
最好用mos作开关
镖头灯未加
PWM[14]
错误：
AON7407 Vgs耐压只有+-8V
无需解决
XT30接口正负颠倒
充电回路加了typec输入mos后 在开关切换瞬间会烧tp5100
取消丝印反显
DSI排线座反了
IMU加热电阻最好加上

Parts:
C32, C33, C34, C38, C39, C40, C44: 10uF; C_0603_1608Metric
C35, C36, C37: 22nF; C_0402_1005Metric
C41, C42, C43, C45: 100nF; C_0402_1005Metric
J12: camera; FH12-24S-0.5SH_1x24-1MP_P0.50mm_Horizontal
R35, R36, R37, R38, R41: 10k; R_0402_1005Metric
R39, R40: 4.7k; R_0402_1005Metric
U8: RT9193-18GB; SOT-23-5
U9: RT9193-15GB; SOT-23-5
U10: RT9193-28GB; SOT-23-5

Connections:
+1V5: C39.2, C42.2, J12.23, U9.5 (VOUT)
+1V8: C38.2, C41.2, J12.22, R38.1, R39.1, R40.1, U8.5 (VOUT)
+2V8: C40.2, C43.2, J12.24, U10.5 (VOUT)
+3V3: C32.1, C33.1, C34.1, C44.1, C45.1, R35.2, R36.2, R37.2, U8.1 (VIN), U9.1 (VIN), U10.1 (VIN); also elsewhere on the board
/CAM_IO0: J12.2, R41.2; also elsewhere on the board
/CAM_IO1: J12.3, R38.2; also elsewhere on the board
/CAM_SCL: J12.6, R39.2; also elsewhere on the board
/CAM_SDA: J12.5, R40.2; also elsewhere on the board
/Camera/LED-strobe: J12.1
/MIPI_RX0_N: J12.21; also elsewhere on the board
/MIPI_RX2_N: J12.18; also elsewhere on the board
/MIPI_RX2_P: J12.19; also elsewhere on the board
/MIPI_RX3_N: J12.11; also elsewhere on the board
/MIPI_RX3_P: J12.12; also elsewhere on the board
/MIPI_RX4_N: J12.9; also elsewhere on the board
/MIPI_RX4_P: J12.10; also elsewhere on the board
GND: C32.2, C33.2, C34.2, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.2, C45.2, J12.7, J12.8, J12.17, J12.20, J12.MP (MountPin), R41.1, U8.2 (GND), U9.2 (GND), U10.2 (GND); also elsewhere on the board
unnamed: C35.2, U8.4 (BP)
unnamed: R35.1, U8.3 (EN)
unnamed: C36.2, U9.4 (BP)
unnamed: R36.1, U9.3 (EN)
unnamed: C37.2, U10.4 (BP)
unnamed: R37.1, U10.3 (EN)

Parts:
C1, C2: 4.7u; C_0603_1608Metric
C3, C4: 470n; C_0402_1005Metric
C5, C6: 100n; C_0402_1005Metric
C7, C8: 10n; C_0402_1005Metric
C9, C10: 22u; C_0603_1608Metric
L1, L2: 10uH; L_Changjiang_FTC303020D
R8, R9: 100k; R_0402_1005Metric
R10: 200k±0.1%; R_0402_1005Metric
R11: 27K±0.1%; R_0402_1005Metric
R12: 68k±0.1%; R_0402_1005Metric
R13: 15K±0.1%; R_0402_1005Metric
U3, U4: SY8303AIC; TSOT-23-8

Connections:
+3V3: C8.1, C10.1, L2.2, R12.2; also elsewhere on the board
+5V: C2.1, C4.1, C7.1, C9.1, L1.2, R10.2, U4.5 (VIN), U4.8 (EN); also elsewhere on the board
+7V2: C1.1, C3.1, U3.5 (VIN), U3.8 (EN); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C9.2, C10.2, R8.1, R9.1, R11.1, R13.1, U3.3 (GND), U3.4 (GND), U4.3 (GND), U4.4 (GND); also elsewhere on the board
unnamed: C5.1, U3.7 (BS)
unnamed: C7.2, R10.1, R11.2, U3.1 (FB)
unnamed: R8.2, U3.2 (FS)
unnamed: C5.2, L1.1, U3.6 (LX)
unnamed: C6.1, U4.7 (BS)
unnamed: C8.2, R12.1, R13.2, U4.1 (FB)
unnamed: R9.2, U4.2 (FS)
unnamed: C6.2, L2.1, U4.6 (LX)

Notes on the sheet:
program switching frequency as 1MHz

Parts:
C46, C47: 100n; C_0402_1005Metric
R42: 33R; R_0603_1608Metric
R43: 0R; R_0603_1608Metric
U11: BMI088; Bosch_LGA-16_4.5x3mm_P0.5mm_LayoutBorder7x1y_ClockwisePinNu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

Connections:
+3V3: C46.1, C47.1, U11.3 (VDD), U11.11 (VDDIO); also elsewhere on the board
/CS1_Accel: U11.14 (CSB1); also elsewhere on the board
/CS2_Gyro: U11.5 (CSB2); also elsewhere on the board
/IMU_SPI2-MISO: R42.1; also elsewhere on the board
/IMU_SPI2-MOSI: U11.9 (SDI); also elsewhere on the board
/IMU_SPI2-SCK: U11.8 (SCK); also elsewhere on the board
/INT1_Accel: U11.16 (INT1); also elsewhere on the board
/INT2_Accel: R43.1, U11.1 (INT2); also elsewhere on the board
/INT3_Gyro: R43.2, U11.12 (INT3); also elsewhere on the board
GND: C46.2, C47.2, U11.2 (NC), U11.4 (GNDIO), U11.6 (GND), U11.7 (PS); also elsewhere on the board
unnamed: R42.2, U11.10 (SDO2), U11.15 (SDO1)

Parts:
C11, C13, C16, C21, C22: 10uF; C_0603_1608Metric
C12, C14, C15, C18, C19, C20, C24, C26, C31: 100nF; C_0402_1005Metric
C17: 4.7uF; C_0603_1608Metric
C23: 8.2nF; C_0402_1005Metric
C25: 60pF; C_0402_1005Metric
C27, C28: 22uF; C_0603_1608Metric
C29, C30: 47uF; C_1206_3216Metric
D2, D4: G; LED_0402_1005Metric
D3: SS54; D_SMA
D5, D6: R; LED_0402_1005Metric
D7: SS34; D_SMA
D8: BV03C; D_SOD-323
J10: USB_C_Receptacle_USB2.0_14P; USB-C-TH_KH-TYPE-C-W-16P-T
J11: Battery; AMASS_XT30APW-M_1x02_P2.50mm_Horizontal
L3: 10uH; L_APV_APH0630
L4: 3.3uH; L_APV_APH0630
Q1, Q2: AON7403; Vishay_PowerPAK_1212-8_Single
R14, R16: 5k; R_0402_1005Metric
R15: 24k/6.8k; R_0402_1005Metric
R17: 4.7k; R_0402_1005Metric
R18, R19, R20: 50k; R_0402_1005Metric
R21, R22: 300mR; R_0805_2012Metric
R23: 1k; R_0402_1005Metric
R24: 3R; R_0402_1005Metric
R25, R27: 100k; R_0402_1005Metric
R26: 22k; R_0402_1005Metric
R28: 50mR; R_0805_2012Metric
R29: 11k; R_0402_1005Metric
R30, R32, R34, R44: 10k; R_0402_1005Metric
R31: 80k; R_0402_1005Metric
R33: 20k; R_0402_1005Metric
SW2: SW_Push_DPDT; SW_E-Switch_EG1271_SPDT
U5: CH224Q; DFN-10-1EP_2x2mm_P0.4mm_EP0.9x1.5mm
U6: TP5100; QFN-16-1EP_4x4mm_P0.65mm_EP2.1x2.1mm_ThermalVias
U7: TPS54620RHLR; VQFN-14_L3.5-W3.5-P0.50-TL-EP_TPS54620RHLR

Connections:
+3V3: R23.2; also elsewhere on the board
+7V2: C27.2, C28.2, C29.2, C30.2, L4.2, R31.2, R33.2; also elsewhere on the board
/Battery/Battery_Power: C20.2, C22.2, J11.2, Q2.5 (D), R28.1, U6.9 (BAT)
GND: C11.2, C12.2, C13.1, C14.1, C15.1, C16.2, C17.2, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C25.2, C26.2, C27.1, C28.1, C29.1, C30.1, C31.2, D7.2 (A), D8.2 (A), J10.A1 (GND), J10.A12 (GND), J10.B1 (GND), J10.B12 (GND), J10.SH (SHIELD), J11.1, R15.2, R20.2, R26.1, R27.1, R30.1, R32.1, R34.1, R44.1, SW2.3 (C), SW2.6 (C), U5.11 (GND), U6.7 (GND), U6.11 (TS), U6.17 (PAD), U7.2 (GND), U7.3 (GND), U7.15 (PwPd); also elsewhere on the board
unnamed: C18.2, R24.2
unnamed: C23.2, R29.2
unnamed: C24.2, L4.1, U7.11 (PH), U7.12 (PH)
unnamed: D2.2 (A), R14.2
unnamed: D2.1 (K), U5.10 (PG)
unnamed: D4.2 (A), D5.2 (A), R16.2
unnamed: D4.1 (K), U6.14 (STDBY)
unnamed: D5.1 (K), U6.15 (CHRG)
unnamed: D6.2 (A), R23.1
unnamed: D6.1 (K), U7.14 (PWRGD)
unnamed: D7.1 (K), L3.1, R24.1, U6.2 (LX), U6.3 (LX)
unnamed: J10.A5 (CC1), U5.7 (CC1)
unnamed: J10.B5 (CC2), U5.6 (CC2)
unnamed: C16.1, C17.1, Q1.5 (D), R25.2, U7.4 (PVIN), U7.5 (PVIN), U7.6 (VIN)
unnamed: Q1.4 (G), R17.1, R18.2
unnamed: C13.2, C15.2, Q2.4 (G), R16.1, R21.2, R22.1, R30.2, U6.1 (VIN), U6.4 (VIN), U6.5 (VIN), U6.16 (VIN)
unnamed: R17.2, SW2.2 (B), SW2.5 (B)
unnamed: R15.1, U5.9 (CFG1)
unnamed: J10.A7 (D-), J10.B7 (D-), U5.5 (DM)
unnamed: J10.A6 (D+), J10.B6 (D+), U5.4 (DP)
unnamed: R19.1, U6.13 (CS)
unnamed: R20.1, U6.12 (RTRICK)
unnamed: C14.2, R19.2, U6.10 (VREG)
unnamed: C19.2, C21.2, L3.2, R28.2, U6.8 (VS)
unnamed: C24.1, U7.13 (BOOT)
unnamed: C25.1, R29.1, U7.8 (COMP)
unnamed: R25.1, R26.2, U7.10 (EN)
unnamed: R27.2, U7.1 (RT/CLK)
unnamed: C26.1, U7.9 (SS/TR)
unnamed: R31.1, R32.2, U7.7 (VSENSE)
Power_IN: D3.1 (K), Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.1 (S), Q2.2 (S), Q2.3 (S), R18.1
TypeC_Power: C11.1, C12.1, D3.2 (A), J10.A4 (VBUS), J10.A9 (VBUS), J10.B4 (VBUS), J10.B9 (VBUS), R14.1, R21.1, R22.2, R44.2, U5.1 (VHV), U5.8 (VBUS)
V_IN: C31.1, D8.1 (K), R33.1, R34.2; also elsewhere on the board

Notes on the sheet:
问题： typec输入时开关无论处在开或关都能正常上电，后级降压稳定，无静态功耗， 但切换时会瞬间烧掉tp5100 从Battery_Power处供电，开关切换一切正常 排查过程： 1.怀疑切换瞬间有倒灌电流使VIN升压，去掉SS34，无果 2.将R22和R23换成和数据手册一样的400mR,无果 3.将CH224Q的诱骗电压从12V降到9V以远离VIN电压上限，无果 4.怀疑开关瞬间后级电容充电大电流，去掉后无果 5.用数字电源在typec处上电9V一切正常，限流2.5A以下开关切换瞬间都会进OCP，2.5A后tp5100烧毁 在Battery_Power处上电用0.1A限流开关切换都不会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
PG引脚拉低阈值
+12V/+9V

Board: 4 copper layers, 80.0 x 32.0 mm, 134 parts (101 on the bottom side), 101 nets.

File RM_Guided_Dart_Base_HW-SMT/RM_Guided_Dart_Base_HW-BOM.csv:

"","Sourced","Placed","References","Value","Footprint","Quantity"
1,"","","C5, C6, C12, C14, C15, C18, C19, C20, C24, C26, C31, C41, C42, C43, C45, C46, C47","100nF","C_0402_1005Metric",17
2,"","","C11, C13, C16, C21, C22, C32, C33, C34, C38, C39, C40, C44","10uF","C_0603_1608Metric",12
3,"","","C9, C10, C27, C28","22u","C_0603_1608Metric",4
4,"","","C1, C2, C17","4.7u","C_0603_1608Metric",3
5,"","","C35, C36, C37","22nF","C_0402_1005Metric",3
6,"","","C3, C4","470n","C_0402_1005Metric",2
7,"","","C7, C8","10n","C_0402_1005Metric",2
8,"","","C29, C30","47uF","C_1206_3216Metric",2
9,"","","C23","8.2nF","C_0402_1005Metric",1
10,"","","C25","60pF","C_0402_1005Metric",1
11,"","","R30, R32, R34, R35, R36, R37, R38, R41, R44","10k","R_0402_1005Metric",9
12,"","","R1, R2, R3, R5, R7","33R","R_0402_1005Metric",5
13,"","","R8, R9, R25, R27","100k","R_0402_1005Metric",4
14,"","","R17, R39, R40","4.7k","R_0402_1005Metric",3
15,"","","R18, R19, R20","50k","R_0402_1005Metric",3
16,"","","R4, R23","1k","R_0402_1005Metric",2
17,"","","R6, R42","33R","R_0603_1608Metric",2
18,"","","R14, R16","5k","R_0402_1005Metric",2
19,"","","R21, R22","300mR","R_0805_2012Metric",2
20,"","","R10","200k±0.1%","R_0402_1005Metric",1
21,"","","R11","27K±0.1%","R_0402_1005Metric",1
22,"","","R12","68k±0.1%","R_0402_1005Metric",1
23,"","","R13","15K±0.1%","R_0402_1005Metric",1
24,"","","R15","24k/6.8k","R_0402_1005Metric",1
25,"","","R24","3R","R_0402_1005Metric",1
26,"","","R26","22k","R_0402_1005Metric",1
27,"","","R28","50mR","R_0805_2012Metric",1
28,"","","R29","11k","R_0402_1005Metric",1
29,"","","R31","80k","R_0402_1005Metric",1
30,"","","R33","20k","R_0402_1005Metric",1
31,"","","R43","0R","R_0603_1608Metric",1
32,"","","L1, L2","10uH","L_Changjiang_FTC303020D",2
33,"","","L3","10uH","L_APV_APH0630",1
34,"","","L4","3.3uH","L_APV_APH0630",1
35,"","","D1, D2, D4","G","LED_0402_1005Metric",3
36,"","","D5, D6","R","LED_0402_1005Metric",2
37,"","","D3","SS54","D_SMA",1
38,"","","D7","SS34","D_SMA",1
39,"","","D8","BV03C","D_SOD-323",1
40,"","","U3, U4","SY8303AIC","TSOT-23-8",2
41,"","","U1","LicheeRV_Nano","LicheeRV_Nano_THT",1
42,"","","U2","XIAO-ESP32-C5-DIP","XIAO-ESP32-C5-SMD",1
43,"","","U5","CH224Q","DFN-10-1EP_2x2mm_P0.4mm_EP0.9x1.5mm",1
44,"","","U6","TP5100","QFN-16-1EP_4x4mm_P0.65mm_EP2.1x2.1mm_ThermalVias",1
45,"","","U7","TPS54620RHLR","VQFN-14_L3.5-W3.5-P0.50-TL-EP_TPS54620RHLR",1
46,"","","U8","RT9193-18GB","SOT-23-5",1
47,"","","U9","RT9193-15GB","SOT-23-5",1
48,"","","U10","RT9193-28GB","SOT-23-5",1
49,"","","U11","BMI088","Bosch_LGA-16_4.5x3mm_P0.5mm_LayoutBorder7x1y_ClockwisePinNumbering",1
50,"","","SW1","SW_Push","SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS",1
51,"","","SW2","SW_Push_DPDT","SW_E-Switch_EG1271_SPDT",1
52,"","","Q1, Q2","AON7403","Vishay_PowerPAK_1212-8_Single",2
53,"","","J4, J9","PWM4","Connector_Servo_JR_3P_2.54mm_WirePad",2
54,"","","J1","CSI","FPC-SMD_22P-P1.00_AFC11-S22ICC-00",1
55,"","","J2","DSI","Hirose_FH26-31S-0.3SHW_2Rows-31Pins-1MP_P0.60mm_Horizontal",1
56,"","","J3","JTAG","JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal",1
57,"","","J5","UART3","JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal",1
58,"","","J6","PWM1","Connector_Servo_JR_3P_2.54mm_WirePad",1
59,"","","J7","PWM2","Connector_Servo_JR_3P_2.54mm_WirePad",1
60,"","","J8","PWM3","Connector_Servo_JR_3P_2.54mm_WirePad",1
61,"","","J10","USB_C_Receptacle_USB2.0_14P","USB-C-TH_KH-TYPE-C-W-16P-T",1
62,"","","J11","Battery","AMASS_XT30APW-M_1x02_P2.50mm_Horizontal",1
63,"","","J12","camera","FH12-24S-0.5SH_1x24-1MP_P0.50mm_Horizontal",1
